# Keil uVision project stm32iap.uvprojx, settings and files
target stm32iap (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32iap +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE
  c include: .\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group source
    ./: startup_stm32f103xe.s
    ./Core/Src/: main.c system_stm32f1xx.c flash.c gpio.c usart.c sdio.c stm32_sdio.c boot.c eeprom.c spi.c
